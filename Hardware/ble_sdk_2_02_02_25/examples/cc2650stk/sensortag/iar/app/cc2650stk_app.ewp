# IAR project cc2650stk_app.ewp, settings and files
configuration FlashOnly_OAD (ARM, debug)
  General.OGChipSelectEditMenu: CC2650F128 TexasInstruments CC2650F128
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: CC2650STK; CC26XX; Display_DISABLE_ALL; EXCLUDE_AUDIO; FACTORY_IMAGE; FEATURE_OAD; GAPROLE_TASK_STACK_SIZE=440; GATT_TI_UUID_128_BIT; HEAPMGR_SIZE=0; ICALL_MAX_NUM_ENTITIES=11; ICALL_MAX_NUM_TASKS=8; POWER_SAVING; USE_ICALL; xdc_runtime_Assert_DISABLE_ALL; xdc_runtime_Log_DISABLE_ALL
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: -f $SRC_EX$/config/build_components.opt; -f ..\stack\build_config.opt; -f ..\config\configPkg\compiler.opt.defs; -f ..\config\iar_boundary.bdef
  ICCARM.CCIncludePath2: $SRC_BLE_CORE$/controller/cc26xx/inc; $SRC_BLE_CORE$/inc; $SRC_EX$/common/cc26xx; $SRC_EX$/examples/sensortag/cc26xx/app; $SRC_EX$/icall/inc; $SRC_EX$/inc; $SRC_EX$/profiles/batt/cc26xx; $SRC_EX$/profiles/dev_info; $SRC_EX$/profiles/hid_dev/cc26xx; $SRC_EX$/profiles/keys; $SRC_EX$/profiles/oad/cc26xx; $SRC_EX$/profiles/roles; $SRC_EX$/profiles/roles/cc26xx; $SRC_EX$/profiles/sensor_profile/cc26xx; $SRC_EX$/target; $SRC_COMMON$/hal/src/inc; $SRC_COMMON$/hal/src/target/_common; $SRC_COMMON$/hal/src/target/_common/cc26xx; $SRC_COMMON$/heapmgr; $SRC_COMMON$/icall/src/inc; $SRC_COMMON$/osal/src/inc; $SRC_COMMON$/services/src/saddr; $SRC_COMMON$/services/src/sdata; $CC26XXWARE$; $TI_RTOS_DRIVERS_BASE$; $TI_RTOS_DRIVERS_BASE$/ti/mw/extflash; $TI_RTOS_DRIVERS_BASE$/ti/mw/sensors; $TI_RTOS_DRIVERS_BASE$/ti/mw/sensortag
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: sensortag_cc2650stk_app.hex
  prebuild: "$XDCROOT$/xs" --xdcpath="$XDCPATH$" iar.tools.configuro -c "$TOOLKIT_DIR$" --cc "$COMPILER_PATH$" --device "$DEVICE$" --compileOptions $COMPILER_ARGS_ROOT_QUOTED$ --linkOptions $LINKER_ARGS_QUOTED$ --profile release --projFile "$PROJ_PATH$" --cfgArgs NO_ROM=1,OAD_IMG_E=1
  postbuild: "$TOOLS_BLE$\oad\oad_image_tool.exe" "FlashOnly_OAD\Exe\sensortag_cc2650stk_app.hex" -t offchip -i app --imgVer 0 -ob "FlashOnly_OAD\Exe\sensortag_cc2650stk_app_oad.bin" -m 0x1000 --r 0x1000
  ILINK.IlinkOutputFile: sensortag_cc2650stk_app.out
  ILINK.IlinkConfigDefines: APP_IMAGE_START=0x1000
  ILINK.IlinkIcfFile: $SRC_EX$/common/cc26xx/iar/cc26xx_app_oad.icf
  ILINK.IlinkExtraOptions: --keep __vector_table; -f ..\config\configPkg\linker.cmd; -f ..\config\iar_boundary.xcl
  ILINK.IlinkAdditionalLibs: $ROM$\common_rom_releases\03282014\common_rom.symbols; $CC26XXWARE$\driverlib\bin\iar\driverlib.lib
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration FlashROM (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: CC2650STK; CC26XX; Display_DISABLE_ALL; EXCLUDE_AUDIO; EXCLUDE_FACTORY_RESET; EXCLUDE_OAD; GAPROLE_TASK_STACK_SIZE=440; GATT_TI_UUID_128_BIT; HEAPMGR_SIZE=0; ICALL_MAX_NUM_ENTITIES=11; ICALL_MAX_NUM_TASKS=8; POWER_SAVING; USE_ICALL; xdc_runtime_Assert_DISABLE_ALL; xdc_runtime_Log_DISABLE_ALL
  ICCARM.CCIncludePath2: $SRC_BLE_CORE$/controller/cc26xx/inc; $SRC_BLE_CORE$/inc; $SRC_EX$/common/cc26xx; $SRC_EX$/examples/sensortag/cc26xx/app; $SRC_EX$/icall/inc; $SRC_EX$/inc; $SRC_EX$/profiles/batt/cc26xx; $SRC_EX$/profiles/dev_info; $SRC_EX$/profiles/hid_dev/cc26xx; $SRC_EX$/profiles/keys; $SRC_EX$/profiles/roles; $SRC_EX$/profiles/roles/cc26xx; $SRC_EX$/profiles/sensor_profile/cc26xx; $SRC_EX$/target; $SRC_COMMON$/hal/src/inc; $SRC_COMMON$/hal/src/target/_common; $SRC_COMMON$/hal/src/target/_common/cc26xx; $SRC_COMMON$/heapmgr; $SRC_COMMON$/icall/src; $SRC_COMMON$/icall/src/inc; $SRC_COMMON$/osal/src/inc; $SRC_COMMON$/services/src/saddr; $SRC_COMMON$/services/src/sdata; $CC26XXWARE$; $TI_RTOS_DRIVERS_BASE$; $TI_RTOS_DRIVERS_BASE$/ti/mw/extflash; $TI_RTOS_DRIVERS_BASE$/ti/mw/sensors; $TI_RTOS_DRIVERS_BASE$/ti/mw/sensortag
  prebuild: "$XDCROOT$/xs" --xdcpath="$XDCPATH$" iar.tools.configuro -c "$TOOLKIT_DIR$" --cc "$COMPILER_PATH$" --device "$DEVICE$" --compileOptions $COMPILER_ARGS_ROOT_QUOTED$ --linkOptions $LINKER_ARGS_QUOTED$ --profile release --projFile "$PROJ_PATH$"
  ILINK.IlinkIcfFile: $SRC_EX$/common/cc26xx/iar/cc26xx_app.icf
  group Application
    $SRC_EX$/examples/sensortag/cc26xx/app/: sensortag.c sensortag.h sensortag_bar.c sensortag_bar.h sensortag_batt.c sensortag_batt.h sensortag_buzzer.c sensortag_buzzer.h sensortag_conn_ctrl.c sensortag_conn_ctrl.h sensortag_factoryreset.c sensortag_factoryreset.h sensortag_hum.c sensortag_hum.h sensortag_io.c sensortag_io.h sensortag_keys.c sensortag_keys.h sensortag_mov.c sensortag_mov.h sensortag_oad.c sensortag_oad.h sensortag_opt.c sensortag_opt.h sensortag_register.c sensortag_register.h sensortag_revision.h sensortag_tmp.c sensortag_tmp.h
    $SRC_EX$/common/cc26xx/: util.c util.h
  group Drivers/ECC
    $SRC_EX$/common/cc26xx/ecc/: ECCROMCC26XX.c ECCROMCC26XX.h
  group Drivers/I2C
    $TI_RTOS_DRIVERS_BASE$/ti/drivers/: I2C.c I2C.h
    $TI_RTOS_DRIVERS_BASE$/ti/drivers/i2c/: I2CCC26XX.c I2CCC26XX.h
  group Drivers/PIN
    $TI_RTOS_DRIVERS_BASE$/ti/drivers/: PIN.h
    $TI_RTOS_DRIVERS_BASE$/ti/drivers/pin/: PINCC26XX.c PINCC26XX.h
  group Drivers/RF
    $TI_RTOS_DRIVERS_BASE$/ti/drivers/rf/: RF.h RFCC26XX_singleMode.c
  group Drivers/SPI
    $TI_RTOS_DRIVERS_BASE$/ti/drivers/: SPI.c SPI.h
    $TI_RTOS_DRIVERS_BASE$/ti/drivers/spi/: SPICC26XXDMA.c SPICC26XXDMA.h
  group Drivers/TRNG
    $SRC_COMMON$/hal/src/target/_common/: TRNGCC26XX.c TRNGCC26XX.h
  group Drivers/UDMA
    $TI_RTOS_DRIVERS_BASE$/ti/drivers/dma/: UDMACC26XX.c UDMACC26XX.h
  group ICall
    $SRC_COMMON$/heapmgr/: heapmgr.h
    $SRC_COMMON$/icall/src/: icall.c icall_cc2650.c icall_platform.h
    $SRC_COMMON$/icall/src/inc/: icall.h
    $SRC_EX$/icall/inc/: icall_addrs.h
  group ICallBLE
    $SRC_EX$/icall/app/: ble_user_config.c icall_api.c
    $SRC_EX$/icall/inc/: ble_user_config.h icall_apimsg.h
  group Include
    $SRC_BLE_CORE$/inc/: gap.h gatt.h hci.h
    $SRC_EX$/profiles/roles/: gapbondmgr.h
    $SRC_EX$/inc/: gapgattserver.h
    $SRC_COMMON$/osal/src/inc/: osal_snv.h
  group Middleware/extflash
    $TI_RTOS_DRIVERS_BASE$/ti/mw/extflash/: ExtFlash.c ExtFlash.h
  group Middleware/sensors
    $TI_RTOS_DRIVERS_BASE$/ti/mw/sensors/: SensorBmp280.c SensorBmp280.h SensorHdc1000.c SensorHdc1000.h SensorI2C.c SensorI2C.h SensorMpu9250.c SensorMpu9250.h SensorOpt3001.c SensorOpt3001.h SensorTmp007.c SensorTmp007.h SensorUtil.c SensorUtil.h
  group Middleware/sensortag
    $TI_RTOS_DRIVERS_BASE$/ti/mw/sensortag/: SensorTagTest.c SensorTagTest.h
  group Profiles
    $SRC_EX$/profiles/sensor_profile/cc26xx/: barometerservice.c barometerservice.h ccservice.c ccservice.h humidityservice.c humidityservice.h ioservice.c ioservice.h irtempservice.c irtempservice.h movementservice.c movementservice.h opticservice.c opticservice.h registerservice.c registerservice.h st_util.c st_util.h
    $SRC_EX$/profiles/batt/cc26xx/: battservice.c battservice.h
    $SRC_EX$/profiles/dev_info/cc26xx/: devinfoservice.c
    $SRC_EX$/profiles/dev_info/: devinfoservice.h
    $SRC_EX$/inc/: gatt_profile_uuid.h
    $SRC_BLE_CORE$/host/: gatt_uuid.c gattservapp_util.c
    $SRC_BLE_CORE$/inc/: gatt_uuid.h
    $SRC_EX$/profiles/oad/cc26xx/: oad.c oad.h oad_constants.h oad_target.h oad_target_external_flash.c
    $SRC_EX$/profiles/roles/cc26xx/: peripheral.c peripheral.h
    $SRC_EX$/profiles/keys/cc26xx/: simplekeys.c
    $SRC_EX$/profiles/keys/: simplekeys.h
  group Startup
    $SRC_EX$/target/: board.c
    $SRC_COMMON$/hal/src/target/: board.h
    ../config/: ccfg_app_ble.c
    $SRC_EX$/examples/sensortag/cc26xx/app/: main.c
  group Tools
    ../config/: app_ble.cfg iar_boundary.bdef iar_boundary.xcl
    $SRC_EX$/common/cc26xx/iar/: cc26xx_app.icf cc26xx_app_oad.icf
