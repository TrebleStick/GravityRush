# IAR project cc2650em_app.ewp, settings and files
configuration FlashROM (ARM, debug)
  General.OGChipSelectEditMenu: CC2650F128 TexasInstruments CC2650F128
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: AUTO_ADV=FALSE; BOARD_DISPLAY_EXCLUDE_UART; CC2650DK_7ID; CC26XX; GAPROLE_TASK_STACK_SIZE=440; HEAPMGR_SIZE=0; ICALL_MAX_NUM_ENTITIES=6; ICALL_MAX_NUM_TASKS=3; POWER_SAVING; USE_ICALL; xBOARD_DISPLAY_EXCLUDE_LCD; xDisplay_DISABLE_ALL; xdc_runtime_Assert_DISABLE_ALL; xdc_runtime_Log_DISABLE_ALL
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: -f $SRC_EX$/config/build_components.opt; -f ..\stack\build_config.opt; -f ..\config\configPkg\compiler.opt.defs; -f ..\config\iar_boundary.bdef
  ICCARM.CCIncludePath2: $SRC_BLE_CORE$/controller/cc26xx/inc; $SRC_BLE_CORE$/inc; $SRC_EX$/common/cc26xx; $SRC_EX$/icall/inc; $SRC_EX$/inc; $SRC_EX$/profiles/accelerometer; $SRC_EX$/profiles/accelerometer/cc26xx; $SRC_EX$/profiles/batt/cc26xx; $SRC_EX$/profiles/dev_info; $SRC_EX$/profiles/hid_dev/cc26xx; $SRC_EX$/profiles/keys; $SRC_EX$/profiles/keys/cc26xx; $SRC_EX$/profiles/proximity; $SRC_EX$/profiles/proximity/cc26xx; $SRC_EX$/profiles/roles; $SRC_EX$/profiles/roles/cc26xx; $SRC_EX$/target; $SRC_COMMON$/hal/src/inc; $SRC_COMMON$/hal/src/target/_common; $SRC_COMMON$/hal/src/target/_common/cc26xx; $SRC_COMMON$/hal/src/target/cc2650/rom; $SRC_COMMON$/heapmgr; $SRC_COMMON$/icall/src/inc; $SRC_COMMON$/osal/src/inc; $SRC_COMMON$/services/src/saddr; $SRC_COMMON$/services/src/sdata; $CC26XXWARE$; $TI_RTOS_DRIVERS_BASE$
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: key_fob_cc2650em_app.hex
  prebuild: "$XDCROOT$/xs" --xdcpath="$XDCPATH$" iar.tools.configuro -c "$TOOLKIT_DIR$" --cc "$COMPILER_PATH$" --device "$DEVICE$" --compileOptions $COMPILER_ARGS_ROOT_QUOTED$ --linkOptions $LINKER_ARGS_QUOTED$ --profile release --projFile "$PROJ_PATH$"
  ILINK.IlinkOutputFile: key_fob_cc2650em_app.out
  ILINK.IlinkIcfFile: $SRC_EX$/common/cc26xx/iar/cc26xx_app.icf
  ILINK.IlinkExtraOptions: --keep __vector_table; -f ..\config\configPkg\linker.cmd; -f ..\config\iar_boundary.xcl
  ILINK.IlinkAdditionalLibs: $ROM$\common_rom_releases\03282014\common_rom.symbols; $CC26XXWARE$\driverlib\bin\iar\driverlib.lib
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    $SRC_EX$/examples/key_fob/cc26xx/app/: bma250.c bma250.h buzzer.c buzzer.h keyfobdemo.c keyfobdemo.h
    $SRC_EX$/common/cc26xx/: board_key.c board_key.h util.c util.h
  group Drivers/Display
    $TI_RTOS_DRIVERS_BASE$/ti/mw/display/: Display.c Display.h DisplayDogm1286.c DisplayDogm1286.h DisplayUart.c DisplayUart.h
  group Drivers/ECC
    $SRC_EX$/common/cc26xx/ecc/: ECCROMCC26XX.c ECCROMCC26XX.h
  group Drivers/PIN
    $TI_RTOS_DRIVERS_BASE$/ti/drivers/: PIN.h
    $TI_RTOS_DRIVERS_BASE$/ti/drivers/pin/: PINCC26XX.c PINCC26XX.h
  group Drivers/RF
    $TI_RTOS_DRIVERS_BASE$/ti/drivers/rf/: RF.h RFCC26XX_singleMode.c
  group Drivers/SPI
    $TI_RTOS_DRIVERS_BASE$/ti/drivers/: SPI.c SPI.h
    $TI_RTOS_DRIVERS_BASE$/ti/drivers/spi/: SPICC26XXDMA.c SPICC26XXDMA.h
  group Drivers/TRNG
    $SRC_COMMON$/hal/src/target/_common/: TRNGCC26XX.c TRNGCC26XX.h
  group Drivers/UDMA
    $TI_RTOS_DRIVERS_BASE$/ti/drivers/dma/: UDMACC26XX.c UDMACC26XX.h
  group ICall
    $SRC_COMMON$/heapmgr/: heapmgr.h
    $SRC_COMMON$/icall/src/: icall.c icall_cc2650.c icall_platform.h
    $SRC_COMMON$/icall/src/inc/: icall.h
    $SRC_EX$/icall/inc/: icall_addrs.h
  group ICallBLE
    $SRC_EX$/icall/app/: ble_user_config.c icall_api.c
    $SRC_EX$/icall/inc/: ble_user_config.h icall_apimsg.h
  group Include
    $SRC_BLE_CORE$/inc/: gap.h gatt.h hci.h
    $SRC_EX$/profiles/roles/: gapbondmgr.h
    $SRC_EX$/inc/: gapgattserver.h
    $SRC_COMMON$/osal/src/inc/: osal_snv.h
  group Profiles
    $SRC_EX$/profiles/accelerometer/cc26xx/: accelerometer.c
    $SRC_EX$/profiles/accelerometer/: accelerometer.h
    $SRC_EX$/profiles/batt/cc26xx/: battservice.c battservice.h
    $SRC_EX$/profiles/dev_info/cc26xx/: devinfoservice.c
    $SRC_EX$/profiles/dev_info/: devinfoservice.h
    $SRC_EX$/inc/: gatt_profile_uuid.h
    $SRC_BLE_CORE$/host/: gatt_uuid.c gattservapp_util.c
    $SRC_BLE_CORE$/inc/: gatt_uuid.h
    $SRC_EX$/profiles/roles/cc26xx/: peripheral.c peripheral.h
    $SRC_EX$/profiles/proximity/cc26xx/: proxreporter.c
    $SRC_EX$/profiles/proximity/: proxreporter.h
    $SRC_EX$/profiles/keys/cc26xx/: simplekeys.c
    $SRC_EX$/profiles/keys/: simplekeys.h
  group Startup
    $SRC_EX$/target/: board.c
    ../config/: ccfg_app_ble.c
    $SRC_EX$/examples/key_fob/cc26xx/app/: main.c
  group Tools
    ../config/: app_ble.cfg iar_boundary.bdef iar_boundary.xcl
    $SRC_EX$/common/cc26xx/iar/: cc26xx_app.icf
