# IAR project cc2650lp_app.ewp, settings and files
configuration FlashROM (ARM, debug)
  General.OGChipSelectEditMenu: CC2650F128 TexasInstruments CC2650F128
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: BOARD_DISPLAY_EXCLUDE_UART; CC2650_LAUNCHXL; CC26XX; Display_DISABLE_ALL; GAPROLE_TASK_STACK_SIZE=440; HEAPMGR_SIZE=0; ICALL_MAX_NUM_ENTITIES=6; ICALL_MAX_NUM_TASKS=3; POWER_SAVING; USE_ICALL; xBOARD_DISPLAY_EXCLUDE_LCD; xdc_runtime_Assert_DISABLE_ALL; xdc_runtime_Log_DISABLE_ALL
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: -f $SRC_EX$/config/build_components.opt; -f ..\stack\build_config.opt; -f ..\config\configPkg\compiler.opt.defs; -f ..\config\iar_boundary.bdef
  ICCARM.CCIncludePath2: $SRC_BLE_CORE$/controller/cc26xx/inc; $SRC_BLE_CORE$/inc; $SRC_EX$/common/cc26xx; $SRC_EX$/examples/simple_peripheral/cc26xx/app; $SRC_EX$/icall/inc; $SRC_EX$/inc; $SRC_EX$/profiles/dev_info; $SRC_EX$/profiles/roles; $SRC_EX$/profiles/roles/cc26xx; $SRC_EX$/profiles/simple_profile; $SRC_EX$/profiles/simple_profile/cc26xx; $SRC_EX$/target; $SRC_COMMON$/hal/src/inc; $SRC_COMMON$/hal/src/target/_common; $SRC_COMMON$/hal/src/target/_common/cc26xx; $SRC_COMMON$/hal/src/target/cc2650/rom; $SRC_COMMON$/heapmgr; $SRC_COMMON$/icall/src/inc; $SRC_COMMON$/osal/src/inc; $SRC_COMMON$/services/src/saddr; $SRC_COMMON$/services/src/sdata; $CC26XXWARE$; $TI_RTOS_DRIVERS_BASE$
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: simple_peripheral_cc2650lp_app.hex
  prebuild: "$XDCROOT$/xs" --xdcpath="$XDCPATH$" iar.tools.configuro -c "$TOOLKIT_DIR$" --cc "$COMPILER_PATH$" --device "$DEVICE$" --compileOptions $COMPILER_ARGS_ROOT_QUOTED$ --linkOptions $LINKER_ARGS_QUOTED$ --profile release --projFile "$PROJ_PATH$"
  ILINK.IlinkOutputFile: simple_peripheral_cc2650lp_app.out
  ILINK.IlinkIcfFile: $SRC_EX$/common/cc26xx/iar/cc26xx_app.icf
  ILINK.IlinkExtraOptions: --keep __vector_table; -f ..\config\configPkg\linker.cmd; -f ..\config\iar_boundary.xcl
  ILINK.IlinkAdditionalLibs: $ROM$\common_rom_releases\03282014\common_rom.symbols; $CC26XXWARE$\driverlib\bin\iar\driverlib.lib
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration FlashOnly_OAD_ImgB (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: BOARD_DISPLAY_EXCLUDE_UART; CC2650_LAUNCHXL; CC26XX; Display_DISABLE_ALL; FEATURE_OAD; FEATURE_OAD_ONCHIP; GAPROLE_TASK_STACK_SIZE=440; HAL_IMAGE_B; HEAPMGR_SIZE=0; ICALL_MAX_NUM_ENTITIES=6; ICALL_MAX_NUM_TASKS=3; IMAGE_INVALIDATE; POWER_SAVING; USE_ICALL; xBOARD_DISPLAY_EXCLUDE_LCD; xdc_runtime_Assert_DISABLE_ALL; xdc_runtime_Log_DISABLE_ALL
  ICCARM.IExtraOptions: -f $SRC_EX$/config/build_components.opt; -f ..\stack\build_config.opt; -f ..\config\configPkg\compiler.opt.defs; -f ..\..\..\oad_target\iar\config\iar_boundary.bdef
  ICCARM.CCIncludePath2: $SRC_BLE_CORE$/controller/cc26xx/inc; $SRC_BLE_CORE$/inc; $SRC_EX$/common/cc26xx; $SRC_EX$/examples/simple_peripheral/cc26xx/app; $SRC_EX$/icall/inc; $SRC_EX$/inc; $SRC_EX$/profiles/dev_info; $SRC_EX$/profiles/oad/cc26xx; $SRC_EX$/profiles/roles; $SRC_EX$/profiles/roles/cc26xx; $SRC_EX$/profiles/simple_profile; $SRC_EX$/profiles/simple_profile/cc26xx; $SRC_EX$/target; $SRC_COMMON$/hal/src/inc; $SRC_COMMON$/hal/src/target/_common; $SRC_COMMON$/hal/src/target/_common/cc26xx; $SRC_COMMON$/hal/src/target/cc2650/rom; $SRC_COMMON$/heapmgr; $SRC_COMMON$/icall/src/inc; $SRC_COMMON$/osal/src/inc; $SRC_COMMON$/services/src/saddr; $SRC_COMMON$/services/src/sdata; $CC26XXWARE$; $TI_RTOS_DRIVERS_BASE$
  prebuild: "$XDCROOT$/xs" --xdcpath="$XDCPATH$" iar.tools.configuro -c "$TOOLKIT_DIR$" --cc "$COMPILER_PATH$" --device "$DEVICE$" --compileOptions $COMPILER_ARGS_ROOT_QUOTED$ --linkOptions $LINKER_ARGS_QUOTED$ --profile release --projFile "$PROJ_PATH$" --cfgArgs NO_ROM=1,OAD_IMG_B=1
  postbuild: "$TOOLS_BLE$\oad\oad_image_tool.exe" "FlashOnly_OAD_ImgB\Exe\simple_peripheral_cc2650lp_app.hex" -t onchip -i app --imgVer 0 --usrId BBBB -ob "FlashOnly_OAD_ImgB\Exe\simple_peripheral_cc2650lp_app_oad.bin" -m 0x9000 --r 0x9000
  ILINK.IlinkConfigDefines: FLASH_ONLY_BUILD=1
  ILINK.IlinkIcfFile: $SRC_EX$/common/cc26xx/iar/cc26xx_app_oad.icf
  ILINK.IlinkExtraOptions: --keep __vector_table; -f ..\config\configPkg\linker.cmd; -f ..\..\..\oad_target\iar\config\iar_boundary.xcl
configuration FlashOnly_OAD_ExtFlash (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: CC2650_LAUNCHXL; CC26XX; Display_DISABLE_ALL; FEATURE_OAD; GAPROLE_TASK_STACK_SIZE=440; HAL_IMAGE_E; HEAPMGR_SIZE=0; ICALL_MAX_NUM_ENTITIES=6; ICALL_MAX_NUM_TASKS=3; POWER_SAVING; USE_ICALL; xdc_runtime_Assert_DISABLE_ALL; xdc_runtime_Log_DISABLE_ALL
  ICCARM.CCIncludePath2: $SRC_BLE_CORE$/controller/cc26xx/inc; $SRC_BLE_CORE$/inc; $SRC_EX$/common/cc26xx; $SRC_EX$/icall/inc; $SRC_EX$/inc; $SRC_EX$/profiles/dev_info; $SRC_EX$/profiles/oad/cc26xx; $SRC_EX$/profiles/roles; $SRC_EX$/profiles/roles/cc26xx; $SRC_EX$/profiles/simple_profile; $SRC_EX$/profiles/simple_profile/cc26xx; $SRC_EX$/target; $SRC_COMMON$/hal/src/inc; $SRC_COMMON$/hal/src/target/_common; $SRC_COMMON$/hal/src/target/_common/cc26xx; $SRC_COMMON$/hal/src/target/cc2650/rom; $SRC_COMMON$/heapmgr; $SRC_COMMON$/icall/src/inc; $SRC_COMMON$/osal/src/inc; $SRC_COMMON$/services/src/saddr; $SRC_COMMON$/services/src/sdata; $CC26XXWARE$; $TI_RTOS_DRIVERS_BASE$; $TI_RTOS_DRIVERS_BASE$/ti/mw/extflash
  prebuild: "$XDCROOT$/xs" --xdcpath="$XDCPATH$" iar.tools.configuro -c "$TOOLKIT_DIR$" --cc "$COMPILER_PATH$" --device "$DEVICE$" --compileOptions $COMPILER_ARGS_ROOT_QUOTED$ --linkOptions $LINKER_ARGS_QUOTED$ --profile release --projFile "$PROJ_PATH$" --cfgArgs NO_ROM=1,OAD_IMG_E=1
  postbuild: "$TOOLS_BLE$\oad\oad_image_tool.exe" "FlashOnly_OAD_ExtFlash\Exe\simple_peripheral_cc2650lp_app.hex" -t offchip -i app --imgVer 0 -ob "FlashOnly_OAD_ExtFlash\Exe\simple_peripheral_cc2650lp_app_oad.bin" -m 0x1000 --r 0x1000
  ILINK.IlinkConfigDefines: APP_IMAGE_START=0x1000
  ILINK.IlinkIcfFile: $SRC_EX$/common/cc26xx/iar/cc26xx_app_oad.icf
  group Application
    $SRC_EX$/common/cc26xx/rcosc/: rcosc_calibration.c rcosc_calibration.h
    $SRC_EX$/examples/simple_peripheral/cc26xx/app/: simple_peripheral.c simple_peripheral.h
    $SRC_EX$/common/cc26xx/: util.c util.h
  group Drivers/Display
    $TI_RTOS_DRIVERS_BASE$/ti/mw/display/: Display.c Display.h DisplayDogm1286.c DisplayDogm1286.h DisplayUart.c DisplayUart.h
  group Drivers/ECC
    $SRC_EX$/common/cc26xx/ecc/: ECCROMCC26XX.c ECCROMCC26XX.h
  group Drivers/PIN
    $TI_RTOS_DRIVERS_BASE$/ti/drivers/: PIN.h
    $TI_RTOS_DRIVERS_BASE$/ti/drivers/pin/: PINCC26XX.c PINCC26XX.h
  group Drivers/RF
    $TI_RTOS_DRIVERS_BASE$/ti/drivers/rf/: RF.h RFCC26XX_singleMode.c
  group Drivers/SPI
    $TI_RTOS_DRIVERS_BASE$/ti/drivers/: SPI.c SPI.h
    $TI_RTOS_DRIVERS_BASE$/ti/drivers/spi/: SPICC26XXDMA.c SPICC26XXDMA.h
  group Drivers/TRNG
    $SRC_COMMON$/hal/src/target/_common/: TRNGCC26XX.c TRNGCC26XX.h
  group Drivers/UDMA
    $TI_RTOS_DRIVERS_BASE$/ti/drivers/dma/: UDMACC26XX.c UDMACC26XX.h
  group ICall
    $SRC_COMMON$/heapmgr/: heapmgr.h
    $SRC_COMMON$/icall/src/: icall.c icall_cc2650.c icall_platform.h
    $SRC_COMMON$/icall/src/inc/: icall.h
    $SRC_EX$/icall/inc/: icall_addrs.h
  group ICallBLE
    $SRC_EX$/icall/app/: ble_user_config.c icall_api.c
    $SRC_EX$/icall/inc/: ble_user_config.h icall_apimsg.h
  group Include
    $SRC_BLE_CORE$/inc/: gap.h gatt.h hci.h
    $SRC_EX$/profiles/roles/: gapbondmgr.h
    $SRC_EX$/inc/: gapgattserver.h
    $SRC_COMMON$/osal/src/inc/: osal_snv.h
  group Middleware/extflash
    $TI_RTOS_DRIVERS_BASE$/ti/mw/extflash/: ExtFlash.c ExtFlash.h
  group Profiles
    $SRC_EX$/profiles/dev_info/cc26xx/: devinfoservice.c
    $SRC_EX$/profiles/dev_info/: devinfoservice.h
    $SRC_EX$/common/cc26xx/: ext_flash_layout.h
    $SRC_EX$/inc/: gatt_profile_uuid.h
    $SRC_BLE_CORE$/host/: gatt_uuid.c gattservapp_util.c
    $SRC_BLE_CORE$/inc/: gatt_uuid.h
    $SRC_EX$/profiles/oad/cc26xx/: oad.c oad.h oad_reset_service.c oad_target_external_flash.c oad_target_internal_flash.c
    $SRC_EX$/profiles/roles/cc26xx/: peripheral.c peripheral.h
    $SRC_EX$/profiles/simple_profile/cc26xx/: simple_gatt_profile.c
    $SRC_EX$/profiles/simple_profile/: simple_gatt_profile.h
    $SRC_EX$/profiles/keys/cc26xx/: simplekeys.c
    $SRC_EX$/profiles/keys/: simplekeys.h
  group Startup
    $SRC_EX$/target/: board.c
    ../config/: ccfg_app_ble.c
    $SRC_EX$/common/cc26xx/rcosc/: ccfg_app_ble_rcosc.c
    $SRC_EX$/examples/simple_peripheral/cc26xx/app/: main.c
  group Tools
    ../config/: app_ble.cfg iar_boundary.bdef iar_boundary.xcl
    $SRC_EX$/common/cc26xx/iar/: cc26xx_app.icf cc26xx_app_oad.icf
