<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\..\..\..\util\bim_extflash\cc2640\iar\bim_extflash.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\app\cc2650lp_app.ewp</path>
  </project>
  <batchBuild/>
</workspace>
