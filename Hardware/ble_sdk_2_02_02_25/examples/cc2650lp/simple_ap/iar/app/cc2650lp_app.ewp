# IAR project cc2650lp_app.ewp, settings and files
configuration FlashROM (ARM, debug)
  General.OGChipSelectEditMenu: CC2650F128 TexasInstruments CC2650F128
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: CC2650_LAUNCHXL; CC26XX; Display_DISABLE_ALL; HEAPMGR_SIZE=0; NPI_MASTER; NPI_USE_UART; POWER_SAVING; USE_DEFAULT_USER_CFG; xdc_runtime_Assert_DISABLE_ALL; xdc_runtime_Log_DISABLE_ALL
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: -f ..\config\configPkg\compiler.opt.defs
  ICCARM.CCIncludePath2: $SRC_BLE_CORE$/inc; $SRC_EX$/common/cc26xx; $SRC_EX$/examples/simple_ap/cc26xx/app/board_cc2650lp; $SRC_EX$/inc; $SRC_EX$/profiles/dev_info; $SRC_EX$/profiles/oad/cc26xx; $SRC_EX$/profiles/oad/sap; $SRC_EX$/profiles/simple_profile/sap; $SRC_EX$/target; $SRC_COMMON$/hal/src/inc; $SRC_COMMON$/hal/src/target/_common; $SRC_COMMON$/hal/src/target/_common/cc26xx; $SRC_COMMON$/hal/src/target/cc2650/rom; $SRC_COMMON$/heapmgr; $SRC_COMMON$/osal/src/inc; $SRC_COMMON$/services/src/saddr; $SRC_COMMON$/services/src/sdata; $CC26XXWARE$; $SAP$; $TI_RTOS_DRIVERS_BASE$
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: simple_ap_cc2650lp_app.hex
  prebuild: "$XDCROOT$/xs" --xdcpath="$XDCPATH$" iar.tools.configuro -c "$TOOLKIT_DIR$" --cc "$COMPILER_PATH$" --device "$DEVICE$" --compileOptions $COMPILER_ARGS_ROOT_QUOTED$ --linkOptions $LINKER_ARGS_QUOTED$ --profile release --projFile "$PROJ_PATH$" --cfgArgs USE_EVENTS=1
  ILINK.IlinkOutputFile: simple_ap_cc2650lp_app.out
  ILINK.IlinkConfigDefines: FLASH_ONLY_BUILD=1
  ILINK.IlinkIcfFile: $SRC_EX$/common/cc26xx/iar/cc26xx_app.icf
  ILINK.IlinkExtraOptions: --keep __vector_table; -f ..\config\configPkg\linker.cmd
  ILINK.IlinkAdditionalLibs: $ROM$\common_rom_releases\03282014\common_rom.symbols; $CC26XXWARE$\driverlib\bin\iar\driverlib.lib; $SAP$/ti/sap/lib/release/sap_uart_pm.aem3; $SAP$/ti/npi/lib/release/npi_uart_pm_cc26xx.aem3
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration FlashROM_Dbg (ARM, debug)
  as the first configuration, except:
  ICCARM.CCIncludePath2: $SRC_BLE_CORE$/inc; $SRC_EX$/common/cc26xx; $SRC_EX$/examples/simple_ap/cc26xx/app; $SRC_EX$/inc; $SRC_EX$/profiles/dev_info; $SRC_EX$/profiles/oad/cc26xx; $SRC_EX$/profiles/oad/sap; $SRC_EX$/profiles/simple_profile/sap; $SRC_EX$/target; $SRC_COMMON$/hal/src/inc; $SRC_COMMON$/hal/src/target/_common; $SRC_COMMON$/hal/src/target/_common/cc26xx; $SRC_COMMON$/hal/src/target/cc2650/rom; $SRC_COMMON$/heapmgr; $SRC_COMMON$/osal/src/inc; $SRC_COMMON$/services/src/saddr; $SRC_COMMON$/services/src/sdata; $CC26XXWARE$; $SAP$; $TI_RTOS_DRIVERS_BASE$; $TI_RTOS_DRIVERS_BASE$/ti/mw/sensortag
  ILINK.IlinkAdditionalLibs: $ROM$\common_rom_releases\03282014\common_rom.symbols; $CC26XXWARE$\driverlib\bin\iar\driverlib.lib
configuration FlashROM_OAD (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: CC2650_LAUNCHXL; CC26XX; Display_DISABLE_ALL; FEATURE_OAD; HEAPMGR_SIZE=0; LAUNCHPAD_SBL; NPI_MASTER; NPI_USE_UART; POWER_SAVING; USE_DEFAULT_USER_CFG; xdc_runtime_Assert_DISABLE_ALL; xdc_runtime_Log_DISABLE_ALL
  prebuild: "$XDCROOT$/xs" --xdcpath="$XDCPATH$" iar.tools.configuro -c "$TOOLKIT_DIR$" --cc "$COMPILER_PATH$" --device "$DEVICE$" --compileOptions $COMPILER_ARGS_ROOT_QUOTED$ --linkOptions $LINKER_ARGS_QUOTED$ --profile release --projFile "$PROJ_PATH$" --cfgArgs USE_EVENTS=1,NO_ROM=1,OAD_IMG_E=1
  ILINK.IlinkConfigDefines: FLASH_ONLY_BUILD=1; APP_IMAGE_START=0x1000; APP_IMAGE_SIZE=0x1E000
  ILINK.IlinkIcfFile: $SRC_EX$/common/cc26xx/iar/cc26xx_app_oad.icf
  group Application
    $SRC_EX$/examples/simple_ap/cc26xx/app/: simple_ap.h simple_ap_no_keys.c
    $SRC_EX$/common/cc26xx/: util.c util.h
  group Assert
    $SRC_COMMON$/hal/src/common/: hal_assert.c
    $SRC_COMMON$/hal/src/inc/: hal_assert.h
  group Board/Devices
    $TI_RTOS_DRIVERS_BASE$/ti/mw/extflash/: ExtFlash.c ExtFlash.h
  group Drivers/Display
    $TI_RTOS_DRIVERS_BASE$/ti/mw/display/: Display.c Display.h DisplayDogm1286.c DisplayDogm1286.h DisplayUart.c DisplayUart.h
  group Drivers/ECC
    $SRC_EX$/common/cc26xx/ecc/: ECCROMCC26XX.c ECCROMCC26XX.h
  group Drivers/PIN
    $TI_RTOS_DRIVERS_BASE$/ti/drivers/: PIN.h
    $TI_RTOS_DRIVERS_BASE$/ti/drivers/pin/: PINCC26XX.c PINCC26XX.h
  group Drivers/SPI
    $TI_RTOS_DRIVERS_BASE$/ti/drivers/: SPI.c SPI.h
    $TI_RTOS_DRIVERS_BASE$/ti/drivers/spi/: SPICC26XXDMA.c SPICC26XXDMA.h
  group Drivers/TRNG
    $SRC_COMMON$/hal/src/target/_common/: TRNGCC26XX.c TRNGCC26XX.h
  group Drivers/UART
    $TI_RTOS_DRIVERS_BASE$/ti/drivers/: UART.c UART.h
    $TI_RTOS_DRIVERS_BASE$/ti/drivers/uart/: UARTCC26XX.c UARTCC26XX.h
  group Drivers/UDMA
    $TI_RTOS_DRIVERS_BASE$/ti/drivers/dma/: UDMACC26XX.c UDMACC26XX.h
  group NPI
    $SAP$/ti/npi/: npi_data.h npi_task.c npi_task.h npi_util.c npi_util.h
  group NPI/Subsystem
    $SAP$/ti/sap/: npi_ss_ble_sap.c npi_ss_ble_sap.h
  group NPI/TL
    $SAP$/ti/npi/: npi_tl.h npi_tl_cc26xx.c
  group NPI/TL/UART
    $SAP$/ti/npi/: npi_tl_uart.h npi_tl_uart_m_cc26xx.c
  group Profiles
    $SRC_EX$/profiles/oad/sap/: oad_sap.c oad_sap.h
    $SRC_EX$/profiles/oad/cc26xx/: oad_target_external_flash.c
    $SRC_EX$/profiles/simple_profile/sap/: simple_gatt_profile.c simple_gatt_profile.h
  group SAPSource
    $SAP$/ti/sap/: sap.c sap.h snp.h snp_rpc.c snp_rpc.h snp_rpc_synchro.c snp_rpc_synchro.h
  group SBL
    $SAP$/ti/sbl/: sbl.c sbl.h sbl_cc26xx.c sbl_cmd.c sbl_cmd.h sbl_image.h sbl_image_ext.c sbl_tl.c sbl_tl.h sbl_tl_cc26xx.c
  group Startup
    $SRC_EX$/examples/simple_ap/cc26xx/app/: board.c main.c
    ../config/: ccfg_app_ble.c
  group Tools
    ../config/: app_ble.cfg
    $SRC_EX$/common/cc26xx/iar/: cc26xx_app.icf cc26xx_app_oad.icf
